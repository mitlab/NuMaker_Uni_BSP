# Keil uVision project NuMaker_Uni_RTC_LCD_Clock.uvproj, settings and files
target RTC_LCD_Clock (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NANO100NE3BN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(42000000) CPUTYPE("Cortex-M0")
  output: I2C_LCD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include;..\..\..\..\Library\NuMaker_Uni_Lib\Include;..\
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group Libraries
    ../../../../Library/StdDriver/src/: rtc.c sys.c clk.c gpio.c i2c.c retarget.c
  group User
    ../: main.c
    ../../../../Library/NuMaker_Uni_Lib/Source/: SYS_init.c I2Cdev.c I2C_SSD1306Z.c PowerDown.c Draw2D.c
