# IAR project PWM_IrDA_NEC.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano100BN series Nuvoton Nano100BN series (Nano100BN,Nano110BN,Nano120BN,Nano130BN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\NuMaker_UNI_Lib\Include; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: PWM_IrDA_NEC.bin
  ILINK.IlinkOutputFile: PWM_IrDA_NEC.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/IAR/: startup_Nano100Series.s
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
  group Libraries
    ../../../../Library/StdDriver/src/: clk.c gpio.c pwm.c retarget.c sys.c
  group User
    ../../../../Library/NuMaker_Uni_Lib/Source/: IrDA_NEC.c SYS_init.c
    ../: main.c
